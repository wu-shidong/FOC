# Keil uVision project FOC.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: FOC +hex
  group Source Group 1
    ./: main.c
  group controller
    ./Componenets/: user_pid.c
  group board
    ./Bsp/: bsp_gpio.c bsp_uart.c
  group application
    ./Application/: BLDC.c
  group library
    ./Lib/: STC32G_Delay.c STC32G_GPIO.c STC32G_NVIC.c STC32G_UART.c STC32G_UART_Isr.c
